# IAR project WESU_DEMO.ewp, settings and files
configuration STEVAL-WESU1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151xE ST STM32L151xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: FIRMWARE_VERSION=0x1100; VECT_TAB_OFFSET=0x20000; WESU_DEMO; USE_WESU; USE_REGS; BLUENRG_MS; USE_HAL_DRIVER; STM32L151xE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STEVAL-WESU1\BlueNRG_Comm; ..\..\..\..\..\Drivers\BSP\STEVAL-WESU1\Platform; ..\..\..\..\..\Drivers\BSP\STEVAL-WESU1\Sensor_Comm; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\Drivers\BSP\Components\lsm6ds3; ..\..\..\..\..\Drivers\BSP\Components\stc3115; ..\..\..\..\..\Middlewares\ST\Sensor_Fusion_Demo\inc; ..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionFX_Library\inc; ..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionAR_Library\inc; ..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionCP_Library\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WESU_DEMO.hex
  postbuild: ielftool.exe --bin --verbose "STEVAL-WESU1\Exe\Project.out" "STEVAL-WESU1\Exe\WESU_DEMO.bin"
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l1xx_flash_offset.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionFX_Library\Lib\osxMotionFX107_CM3_IAR_ot.a; ..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionAR_Library\Lib\osxMotionAR120_CM3_IAR_ot.a; ..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionCP_Library\Lib\osxMotionCP100_CM3_IAR_ot.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l151xe.s
  group Application/User
    ../Src/: algorithms.c BlueST_Protocol.c clock.c console.c low_power.c main.c stm32l1xx_hal_msp.c stm32l1xx_it.c wesu_config.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../Drivers/BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
    ../../../../../Drivers/BSP/Components/stc3115/: stc3115.c stc3115_Driver_00.c
  group Drivers/BSP/STEVAL-WESU1/BNRG
    ../../../../../Drivers/BSP/STEVAL-WESU1/BlueNRG_Comm/: stm32_bluenrg_ble.c
  group Drivers/BSP/STEVAL-WESU1/Platform
    ../../../../../Drivers/BSP/STEVAL-WESU1/Platform/: wesu.c wesu_charger.c wesu_gg.c wesu_rtc.c
  group Drivers/BSP/STEVAL-WESU1/Sensors
    ../../../../../Drivers/BSP/STEVAL-WESU1/Sensor_Comm/: wesu_accelero.c wesu_gyro.c wesu_magneto.c wesu_pressure.c wesu_sensors.c wesu_temperature.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c
  group Middlewares/OSX_MotionAR
    ../../../../../Middlewares/ST/STM32_OSX_MotionAR_Library/Lib/: osxMotionAR120_CM3_IAR_ot.a
  group Middlewares/OSX_MotionCP
    ../../../../../Middlewares/ST/STM32_OSX_MotionCP_Library/Lib/: osxMotionCP100_CM3_IAR_ot.a
  group Middlewares/OSX_MotionFX
    ../../../../../Middlewares/ST/STM32_OSX_MotionFX_Library/Lib/: osxMotionFX107_CM3_IAR_ot.a
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c list.c osal.c
