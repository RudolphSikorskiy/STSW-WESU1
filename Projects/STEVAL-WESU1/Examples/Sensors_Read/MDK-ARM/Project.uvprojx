# Keil uVision project Project.uvprojx, settings and files
target SENSORS READ (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L151VE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Sensors_Read +hex
  c flags: OneElfS=1 wLevel=2
  c define: FIRMWARE_VERSION=0x1100,VECT_TAB_OFFSET=0x20000,USE_WESU,BLUENRG_MS,USE_HAL_DRIVER,STM32L151xE
  c misc: --C99 --gnu --diag_suppress 1295 --diag_suppress 1293
  c include: ..\Inc;..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STEVAL-WESU1\BlueNRG_Comm;..\..\..\..\..\Drivers\BSP\STEVAL-WESU1\Platform;..\..\..\..\..\Drivers\BSP\STEVAL-WESU1\Sensor_Comm;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\Drivers\BSP\Components\lsm6ds3;..\..\..\..\..\Drivers\BSP\Components\stc3115;..\..\..\..\..\Middlewares\ST\Sensor_Fusion_Demo\inc;..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionAR_Library\inc;..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionCP_Library\inc;..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionFX_Library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x13000
  memory RVCT10: RAM 0x20013000 size 0x1000
  scatter file: .\SENSORS_READ.sct
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Inc/: stm32l151xe.h system_stm32l1xx.h
    ../Src/: system_stm32l1xx.c
  group Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/includes
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_hal_aci.c bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_l2cap_aci.c
  group Middlewares/ST/STM32_BlueNRG/Interface
    ../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c osal.c list.c
  group Examples/Sensors_Read/Src
    ../Src/: stm32l1xx_hal_msp.c clock.c stm32l1xx_it.c algorithms_examples.c BlueST_Protocol_examples.c console_examples.c main_examples.c wesu_config_examples.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_usart.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_rcc.c stm32l1xx_hal_crc.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal.c stm32l1xx_hal_flash.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_adc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_i2c.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_iwdg.c
  group Examples/Sensors_Read/MDK-ARM
    ./: startup_stm32l151xe.s
  group Drivers/BSP/STEVAL-WESU1/BlueNRG_Comm
    ../../../../../Drivers/BSP/STEVAL-WESU1/BlueNRG_Comm/: stm32_bluenrg_ble.c
  group Drivers/BSP/STEVAL-WESU1/Platform
    ../../../../../Drivers/BSP/STEVAL-WESU1/Platform/: wesu.c wesu_charger.c wesu_gg.c wesu_rtc.c
  group Drivers/BSP/STEVAL-WESU1/Sensors_Comm
    ../../../../../Drivers/BSP/STEVAL-WESU1/Sensor_Comm/: wesu_accelero.c wesu_gyro.c wesu_magneto.c wesu_pressure.c wesu_sensors.c wesu_temperature.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/stc3115/: stc3115_Driver_00.c stc3115.c
    ../../../../../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../Drivers/BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
